SUMMARY="ELF2UF2 tool provided by the Pico SDK"

require pico-sdk-tools.inc
